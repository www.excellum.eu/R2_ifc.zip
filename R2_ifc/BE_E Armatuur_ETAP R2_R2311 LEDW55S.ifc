Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-14T16:07:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 14 16:07:50 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{46E30863-F92A-4979-8D38-2E94AD8C3637}\ifc * Database version: 5507 * Database creation date: Tue Jun 14 16:07:50 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 14 16:07:50 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 14 16:07:50 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: R2311 LEDW55S, Dummy:R2311 LEDW55S:207356
In: Level 1
Type - Material: BE Armatuur, BE_G Glas lamp
Type - Constraints - Default Elevation: 1000 mm; WT_H Behuizing: R231; WT_H Bevestiging: Pendel - 2 pendelkabels; WT_H Breedte: 275 mm; WT_H Grid_breedte: 600 mm; WT_H Grid_hoogte: 600 mm; WT_H Halve breedte: 137.5 mm; WT_H Halve breedte negatief: -137.5 mm; WT_H Halve hoogte: 25 mm; WT_H Halve hoogte negatief: -25 mm; WT_H Halve hoogte symbool: 137.5 mm; WT_H Halve lengte: 615 mm; WT_H Halve lengte negatief: -615 mm; WT_H Hoogte: 50 mm; WT_H Inbouwdiepte: 92 mm; WT_H Inbouwdiepte negatief: -92 mm; WT_H Lengte: 1230 mm; WT_H Lichtbron_breedte: 247.5 mm; WT_H Lichtbron_lengte: 1107 mm; WT_H Opbouw: no; WT_H Pendel horizontale armatuurmontage: yes; WT_H Referentie: Pendel - horizontale armatuurmontage; WT_H Rotatie in vlak: 0 deg; WT_H Rotatie rond as: 0 deg; WT_H Rotatie uit vlak: 0 deg; WT_H Symbool plafond hoogte: 275 mm; WT_H Symbool plafond lengte: 1230 mm; WT_H Symbool straal: 0 mm; WT_H Symbool wand hoogte: 275 mm; WT_H Symbool wand lengte: 1230 mm; WT_H Uitsteek: -1 mm; WT_H Vorm_geen balk: no
Type - Dimensions - BE_G Breedte: 275 mm; BE_G Diameter: 0 mm; BE_G Hoogte: 45 mm; BE_G Lengte: 1230 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 0 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 0 W
Type - Graphics - WT_V Symbool plafond: Standaard; WT_V Symbool wand: Geen
Type - Identity Data - BE_I Bestelcode: R2311/LEDW55S; Manufacturer: ETAP; Model: R2; Type Name: R2311 LEDW55S; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - WT_V Materiaal armatuur: BE Armatuur; WT_V Materiaal optic: BE_G Glas lamp
Type - Model Properties - WT_I Armatuurrendement: 1; WT_I IP: 20; WT_I Kleur: wit; WT_I Montage: pendel; WT_I Optiek: diffusor; WT_I Pendelhoogte_max: 1000 mm; WT_I Type: individueel; WT_I UGR: <=19; WT_I Vorm: langwerpig; WT_I VSA: S
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c01_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP R2 - lichtbron - LED: R2311_LEDW55_S; WT_I Aantal lampen: 0; WT_I Lampkleur: 3000; WT_I Lamptype: Low PowerLed; WT_I Lichtverdeling: zeer breedstralend; WT_I Lumen: 5550 lm
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: R2311 LEDW55S
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Offset lichtbron: 245 mm; WT_H Pendelhoogte: 200 mm
Construction - WT_V Laatste armatuur lichtgevende: no; WT_V Pendelhoogte: 200 mm
Dimensions - Area: 2.05302 m2; Volume: 0.0811805 m3
Electrical - Circuiting - Electrical Data: c01_Elektrische voeding 230 V/1-0 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 73
Other - Family: Dummy: R2311 LEDW55S; Family and Type: Dummy: R2311 LEDW55S; Schedule Level: Level: Level 1; Type: Dummy: R2311 LEDW55S; Type Id: Dummy: R2311 LEDW55S
Phasing - Phase Created: 469492
